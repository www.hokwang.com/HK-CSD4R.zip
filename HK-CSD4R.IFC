Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-CSD4R.IFC
Time: 2022-01-04T03:21:51
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: A0130-0029_HK-CSDX3_轉角接頭
In: Default Storey
PredefinedType: ELEMENT; Material: PP 單聚物

# IfcBuildingElementProxy: A0130-0037_HK-CSDX3_皂液出皂口
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0056 HK-CSDX5_感應器護蓋-A1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0057 HK-CSDX5_固定螺帽
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0058_HK-CSDX5_尼龍華司
In: Default Storey
PredefinedType: ELEMENT; Material: 尼龍 101

# IfcBuildingElementProxy: F0330-0004 HK-CSDX5R_感應器基板組
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: G0130-0016 HK-CSDX5_橡膠華司(上)_A1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0130-0017 HK-CSDX5_橡膠華司(下)
In: Default Storey
PredefinedType: ELEMENT; Material: NBR

# IfcBuildingElementProxy: G0130-0018 HK-CSDX5_防水環
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: HK-CSD_新感應器
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: K0130-0005 HK-CSDX5_前方銘版
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 圓角2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 圓角4
In: Default Storey
PredefinedType: ELEMENT
